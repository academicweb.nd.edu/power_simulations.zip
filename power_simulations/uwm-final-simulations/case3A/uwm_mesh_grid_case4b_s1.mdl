simulink model "uwm_mesh_grid_case4b_s1"  (Simulink 7.4)
settings: Solver=ode45  StartTime=0.0  StopTime=4.0  RelTol=1e-4
undefined symbols (not defined in the file or in its folder): D1, Delta, dfilt, DiscIntNeverNeededParam
libraries: powerlib x86, powerlib_extras x20, dsparch4 x6
(part 3 of 3)

== system uwm_mesh_grid_case4b_s1/measurement feeder C4/frequency estimator (discrete)/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Relational Operator/1 -> Discrete-Time Integrator/2
  Discrete-Time Integrator/State -> Gain1/1
  Gain1/1 -> Abs/1
  Constant1/1 -> Relational Operator/2, Math Function/2
  Abs/1 -> Relational Operator/1, Math Function/1
  In1/1 -> Discrete-Time Integrator/1
  Discrete-Time Integrator/1 -> Out1/1
  IC/1 -> Discrete-Time Integrator/3
  Math Function/1 -> IC/1

== system uwm_mesh_grid_case4b_s1/microsource/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case4b_s1/microsource/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case4b_s1/genset/genset  controller/P-w droop/limiter ==
  In1 : Inport
  Integrator1 : Integrator  UpperSaturationLimit=0  LowerSaturationLimit=-2*pi
  Integrator2 : Integrator  UpperSaturationLimit=2*pi  LowerSaturationLimit=0
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim2 : Gain  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim3 : Gain  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim4 : Gain  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Saturation2/1 -> Sum3/1
  Saturation1/1 -> Sum3/2
  Sum2/1 -> Saturation1/1
  Integrator2/1 -> Sum2/2
  Kplim1/1 -> Sum2/1
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  Sum9/1 -> Saturation2/1
  Integrator1/1 -> Sum9/2
  Kplim/1 -> Sum9/1
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Kilim2/1 -> Sum4/1
  Plimit/1 -> Kilim2/1
  In1/1 -> Kilim3/1
  Kilim3/1 -> Sum4/2, Sum1/1
  Plimit1/1 -> Kilim4/1
  Kilim4/1 -> Sum1/2

== system uwm_mesh_grid_case4b_s1/genset/genset  controller/Q-E droop/PI-Control ==
  In1 : Inport
  Constant1 : Constant  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Gain : Gain  Gain=1000  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=10  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  InitialCondition=.88  UpperSaturationLimit=1  LowerSaturationLimit=-1
  Sum1 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum1/1 -> Out1/1
  Sum4/1 -> Sum1/1
  Constant1/1 -> Sum1/2

== system uwm_mesh_grid_case4b_s1/genset/genset  controller/ic_engine gpvernor/IC_engine ==
  fuel_cmd : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wr : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Delay : TransportDelay  DelayTime=.022
  Friction_losses : Fcn  Expr=u(1)*u(1)*u(2)
  Fuel_torque : Fcn  Expr=u(1)*3.6*11.8238*0.47*1000
  Mux : Mux  Inputs=2
  Mux1 : Mux  Inputs=2
  Power Limit : Saturate  UpperLimit=1  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum : Sum  Inputs=|+-  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Torque_to_power_pu : Fcn  Expr=u(1)*u(2)/12500
  mech_losses : Constant  Value=0.36  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmech : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Fuel_torque/1 -> Delay/1
  fuel_cmd/1 -> Fuel_torque/1
  Delay/1 -> Mux/1
  wr/1 -> Mux/2, Mux1/1
  mech_losses/1 -> Mux1/2
  Mux1/1 -> Friction_losses/1
  Mux/1 -> Torque_to_power_pu/1
  Torque_to_power_pu/1 -> Sum/1
  Friction_losses/1 -> Sum/2
  Sum/1 -> Power Limit/1
  Power Limit/1 -> Pmech/1

== system uwm_mesh_grid_case4b_s1/genset/genset  controller/ic_engine gpvernor/governor ==
  Pmeas : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wr : Inport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Gain : Gain  Gain=20  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Gain1 : Gain  Gain=10  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Integrator : Integrator  LimitOutput=on  UpperSaturationLimit=10  LowerSaturationLimit=-10
  Sum : Sum  Inputs=-+|  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=++|  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum2 : Sum  Inputs=++|  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Te_cmd_t0_fuel : Fcn  Expr=u(1)/1.6
  Torque_limit : Saturate  UpperLimit=1000  LowerLimit=-1000  OutDataType=fixdt(1, 16)  OutScaling=2^0
  fuel_cmd : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  w/1 -> Sum/2
  wr/1 -> Sum/1
  Sum/1 -> Integrator/1, Gain1/1
  Integrator/1 -> Gain/1
  Gain/1 -> Sum1/1
  Gain1/1 -> Sum1/2
  Pmeas/1 -> Sum2/1
  Sum1/1 -> Sum2/2
  Sum2/1 -> Torque_limit/1
  Torque_limit/1 -> Te_cmd_t0_fuel/1
  Te_cmd_t0_fuel/1 -> fuel_cmd/1
