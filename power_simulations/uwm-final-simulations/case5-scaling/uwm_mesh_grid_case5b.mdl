simulink model "uwm_mesh_grid_case5b"  (Simulink 7.5)
settings: Solver=ode45  StartTime=0.0  StopTime=3.0  RelTol=1e-4
undefined symbols (not defined in the file or in its folder): D1, Delta, dfilt, DiscIntNeverNeededParam
libraries: powerlib x350, powerlib_extras x93, dsparch4 x16
(part 2 of 8)

== system uwm_mesh_grid_case5b/4 kW e-board10 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=4000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3

== system uwm_mesh_grid_case5b/4 kW e-board11 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=4000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3

== system uwm_mesh_grid_case5b/4 kW e-board12 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=2000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3

== system uwm_mesh_grid_case5b/4 kW e-board2 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=4000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3

== system uwm_mesh_grid_case5b/4 kW e-board3 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=4000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3

== system uwm_mesh_grid_case5b/4 kW e-board4 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=4000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3

== system uwm_mesh_grid_case5b/4 kW e-board5 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=4000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3

== system uwm_mesh_grid_case5b/4 kW e-board6 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=4000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3

== system uwm_mesh_grid_case5b/4 kW e-board7 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=4000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3

== system uwm_mesh_grid_case5b/4 kW e-board8 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=2000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3

== system uwm_mesh_grid_case5b/4 kW e-board9 ==
  reset : Inport
  priority : Inport  Port=2
  shed_load : Inport  Port=3
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  L1 : powerlib/Elements/Three-Phase Series RLC Load  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  Configuration=Y (grounded)  NominalVoltage=208  NominalFrequency=60  ActivePower=4000  InductivePower=0  CapacitivePower=0  Measurements=None
  Mux1 : Mux  Inputs=2
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS 1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Three-Phase Breaker2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=closed  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[50]  External=on  BreakerResistance=0.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  f-estimator : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic3
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  state : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=6  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  reset/1 -> load shedding logic/1
  Current Measurement/1 -> RMS 1/1
  Voltage  Measurement/1 -> "RMS "/1, f-estimator/1(v)
  f-estimator/1(w) -> load shedding logic/2, w/1
  "RMS "/1 -> load shedding logic/3
  RMS 1/1 -> load shedding logic/4
  load shedding logic/1 -> Three-Phase Breaker2/1, state/1
  priority/1 -> load shedding logic/5
  Three-Phase V-I Measurement1/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement1/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux1/1
  RMS block/1 -> Mux1/2
  Mux1/1 -> RMS/1
  shed_load/1 -> load shedding logic/6
  connections:
  Voltage  Measurement/LConn1 -- Current Measurement/LConn1 -- Three-Phase V-I Measurement1/RConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1
  Current Measurement/RConn1 -- Three-Phase Breaker2/LConn1
  L1/LConn1 -- Three-Phase Breaker2/RConn1
  L1/LConn2 -- Three-Phase Breaker2/RConn2
  L1/LConn3 -- Three-Phase Breaker2/RConn3
  Three-Phase V-I Measurement1/LConn1 -- A/RConn1
  Three-Phase V-I Measurement1/LConn2 -- B/RConn1
  Three-Phase V-I Measurement1/LConn3 -- C/RConn1
  Three-Phase V-I Measurement1/RConn2 -- Three-Phase Breaker2/LConn2
  Three-Phase V-I Measurement1/RConn3 -- Three-Phase Breaker2/LConn3
