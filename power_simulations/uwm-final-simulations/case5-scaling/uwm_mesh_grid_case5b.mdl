simulink model "uwm_mesh_grid_case5b"  (Simulink 7.5)
settings: Solver=ode45  StartTime=0.0  StopTime=3.0  RelTol=1e-4
undefined symbols (not defined in the file or in its folder): D1, Delta, dfilt, DiscIntNeverNeededParam
libraries: powerlib x350, powerlib_extras x93, dsparch4 x16
(part 5 of 8)

== system uwm_mesh_grid_case5b/microsource5 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5b/microsource6 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5b/microsource7 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5b/microsource8 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5b/microsource9 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5b/reset pulses ==
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  pulse : Subsystem  mask{tstart=tpulse(1), dt=.1}
  pulse1 : Subsystem  mask{tstart=tpulse(2), dt=.1}
  Out1 : Outport
  wires:
  pulse/1(Out1) -> Sum/1
  pulse1/1(Out1) -> Sum/2
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5b/smart coupler1 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler10 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler11 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler12 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler13 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler14 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler15 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler2 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler3 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler4 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler5 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler6 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler7 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler8 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/smart coupler9 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5b/2 kW e-board1/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag0  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/2 kW e-board5/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag1  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/2 kW e-board9/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag2  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board1/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag3  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board10/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag4  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board11/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag5  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2
