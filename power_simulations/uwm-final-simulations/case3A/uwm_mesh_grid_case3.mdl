simulink model "uwm_mesh_grid_case3"  (Simulink 7.5)
settings: Solver=ode45  StartTime=0.0  StopTime=8.0  RelTol=1e-4
undefined symbols (not defined in the file or in its folder): bits, D1, Delta, dfilt, DiscIntNeverNeededParam
libraries: powerlib x86, powerlib_extras x15, simulink x13, dspswit3 x4, dsparch4 x2
(part 2 of 3)

== system uwm_mesh_grid_case3/measurement feeder C7 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  a : PMIOPort  Port=3  Side=Right
  b : PMIOPort  Port=4  Side=Right
  C : PMIOPort  Port=5  Side=Left
  c : PMIOPort  Port=6  Side=Right
  Vabc : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Iabc : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS (V-I) : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> Vabc/1, RMS block1/1, 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> Iabc/1, RMS block/1, 3-phase  Instantaneous  Active & Reactive Power/2
  Mux/1 -> RMS (V-I)/1
  RMS block/1 -> Mux/1
  RMS block1/1 -> Mux/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  c/RConn1 -- Three-Phase V-I Measurement/RConn3
  C/RConn1 -- Three-Phase V-I Measurement/LConn3
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  a/RConn1 -- Three-Phase V-I Measurement/RConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  A/RConn1 -- Three-Phase V-I Measurement/LConn1

== system uwm_mesh_grid_case3/measurement feeder C9 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement1 : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  freq : Subsystem  AncestorBlock=|
      | UWM_blocks/frequency
      | measurement
      | (zero-crossings)
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  a : PMIOPort  Port=3  Side=Right
  b : PMIOPort  Port=4  Side=Right
  C : PMIOPort  Port=5  Side=Left
  c : PMIOPort  Port=6  Side=Right
  Vabc : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Iabc : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  PQ : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS (V-I) : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement1/1 -> Vabc/1, RMS block1/1, 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement1/2 -> Iabc/1, RMS block/1, 3-phase  Instantaneous  Active & Reactive Power/2
  Mux/1 -> RMS (V-I)/1
  RMS block/1 -> Mux/1
  RMS block1/1 -> Mux/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  freq/1(w (Hz)) -> w/1
  connections:
  c/RConn1 -- Three-Phase V-I Measurement1/RConn3
  C/RConn1 -- Three-Phase V-I Measurement1/LConn3
  b/RConn1 -- Three-Phase V-I Measurement1/RConn2
  freq/LConn1 -- Three-Phase V-I Measurement1/RConn1 -- a/RConn1
  B/RConn1 -- Three-Phase V-I Measurement1/LConn2
  A/RConn1 -- Three-Phase V-I Measurement1/LConn1

== system uwm_mesh_grid_case3/microsource ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  Current Measurement : powerlib/Measurements/Current Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=3
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  m : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas)
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas)
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Mux/1 -> m/1
  Voltage Measurement/1 -> Mux/1
  Current Measurement/1 -> Mux/2
  Gain/1 -> Mux/3
  connections:
  Three-Phase V-I Measurement/RConn2 -- b/RConn1 -- Voltage Measurement/LConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  Current Measurement/RConn1 -- a/RConn1
  Three-Phase V-I Measurement/RConn1 -- Current Measurement/LConn1 -- Voltage Measurement/LConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case3/reset pulses ==
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  pulse : Subsystem  mask{tstart=tpulse(1), dt=.1}
  pulse1 : Subsystem  mask{tstart=tpulse(2), dt=.1}
  Out1 : Outport
  wires:
  pulse/1(Out1) -> Sum/1
  pulse1/1(Out1) -> Sum/2
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case3/smart coupler2 ==
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  Mux : Mux  Inputs=2
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Step : Step  Time=10  Before=1  SampleTime=0
  Transfer Fcn : TransferFcn  Numerator=[10]  Denominator=[1 10]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  wires:
  Step/1 -> Level-2 M-file S-Function/2, Scope/2
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Mux/1
  Mux/1 -> Scope/3
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case3/4 kW e-board5/trip ==
  Reset : Inport
  V : Inport  Port=2
  I : Inport  Port=3
  Compare To Constant : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=>=  const=100  LogicOutDataTypeMode=boolean
  Compare To Constant1 : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=<=  const=59.8  LogicOutDataTypeMode=boolean
  Compare To Constant2 : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=<=  const=59.5  LogicOutDataTypeMode=boolean
  Compare To Constant3 : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=>=  const=59.9  LogicOutDataTypeMode=boolean
  Compare To Constant4 : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=<=  const=58.6  LogicOutDataTypeMode=boolean
  Compare To Constant5 : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=<=  const=100  LogicOutDataTypeMode=boolean
  Mux : Mux
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  frequency estimator (discrete) : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic  Parameters=p
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  trip : Outport  Port=2
  Irms : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vrms : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  "RMS "/1 -> Compare To Constant/1, Irms/1
  I/1 -> "RMS "/1
  Reset/1 -> load shedding logic/1
  Compare To Constant/1 -> load shedding logic/2
  load shedding logic/1 -> trip/1
  V/1 -> frequency estimator (discrete)/1(v), RMS1/1
  frequency estimator (discrete)/1(w) -> Compare To Constant1/1, w/1, Compare To Constant2/1, Compare To Constant3/1, Compare To Constant4/1
  Compare To Constant1/1 -> Mux/1
  Compare To Constant2/1 -> Mux/2
  Compare To Constant3/1 -> Mux/3
  Compare To Constant4/1 -> Mux/4
  RMS1/1 -> Compare To Constant5/1, Vrms/1
  Compare To Constant5/1 -> load shedding logic/3
  Mux/1 -> load shedding logic/4

== system uwm_mesh_grid_case3/4 kW e-board6/trip ==
  Reset : Inport
  V : Inport  Port=2
  I : Inport  Port=3
  Compare To Constant : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=>=  const=100  LogicOutDataTypeMode=boolean
  Compare To Constant1 : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=<=  const=59.8  LogicOutDataTypeMode=boolean
  Compare To Constant2 : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=<=  const=59.5  LogicOutDataTypeMode=boolean
  Compare To Constant3 : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=>=  const=59.9  LogicOutDataTypeMode=boolean
  Compare To Constant4 : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=<=  const=58.6  LogicOutDataTypeMode=boolean
  Compare To Constant5 : simulink/Logic and Bit Operations/Compare To Constant  SystemSampleTime=-1  relop=<=  const=100  LogicOutDataTypeMode=boolean
  Mux : Mux
  "RMS " : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  RMS1 : powerlib_extras/Measurements/RMS  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  f1=60
  frequency estimator (discrete) : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  load shedding logic : M-S-Function  FunctionName=load_shedding_logic  Parameters=p
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  trip : Outport  Port=2
  Irms : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vrms : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  "RMS "/1 -> Compare To Constant/1, Irms/1
  I/1 -> "RMS "/1
  Reset/1 -> load shedding logic/1
  Compare To Constant/1 -> load shedding logic/2
  load shedding logic/1 -> trip/1
  V/1 -> frequency estimator (discrete)/1(v), RMS1/1
  frequency estimator (discrete)/1(w) -> Compare To Constant1/1, w/1, Compare To Constant2/1, Compare To Constant3/1, Compare To Constant4/1
  Compare To Constant1/1 -> Mux/1
  Compare To Constant2/1 -> Mux/2
  Compare To Constant3/1 -> Mux/3
  Compare To Constant4/1 -> Mux/4
  RMS1/1 -> Compare To Constant5/1, Vrms/1
  Compare To Constant5/1 -> load shedding logic/3
  Mux/1 -> load shedding logic/4

== system uwm_mesh_grid_case3/external storage/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  limiter : Subsystem
  mP droop : Gain  Gain=2.6928  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2

== system uwm_mesh_grid_case3/external storage/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1

== system uwm_mesh_grid_case3/freq_trip/Triggered Subsystem ==
  In1 : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Trigger : TriggerPort  TriggerType=falling
  Out1 : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  In1/1 -> Out1/1

== system uwm_mesh_grid_case3/genset/genset  controller ==
  wr : Inport
  Vabc : Inport  Port=2
  Iabc : Inport  Port=3
  Preq : Inport  Port=4
  Ereq1 : Inport  Port=5
  Gain : Gain  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  P-w droop : Subsystem
  PVQ computation : Subsystem
  Q-E droop : Subsystem
  exciter : Subsystem
  ic_engine gpvernor : Subsystem
  Pmech : Outport
  Vf : Outport  Port=2
  w : Outport  Port=3
  wires:
  P-w droop/1(w) -> w/1, ic_engine gpvernor/3(w)
  PVQ computation/1(P_pu) -> P-w droop/2(P), ic_engine gpvernor/2(Pmeas)
  PVQ computation/3(Q_pu) -> Q-E droop/2(Q)
  Q-E droop/1(Vpk) -> exciter/2(Ef_mcd_wr)
  ic_engine gpvernor/1(Pmech) -> Pmech/1
  Vabc/1 -> PVQ computation/1(Vabc)
  Iabc/1 -> PVQ computation/2(Iabc)
  exciter/1(Ef) -> Vf/1
  Preq/1 -> P-w droop/1(P_req)
  Ereq1/1 -> Q-E droop/3(E_req)
  PVQ computation/2(Vt) -> Q-E droop/1(v_meas)
  Gain/1 -> ic_engine gpvernor/1(wr), exciter/1(wr)
  wr/1 -> Gain/1

== system uwm_mesh_grid_case3/main grid/PC1 ==
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L  Capacitance=1/(336*2*pi*60)  Measurements=None
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  connections:
  A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Three-Phase Series RLC Branch3/RConn1 -- A/RConn1
  Three-Phase Series RLC Branch3/RConn2 -- B/RConn1
  Three-Phase Series RLC Branch3/RConn3 -- C/RConn1

== system uwm_mesh_grid_case3/measurement feeder C1/freq ==
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Counter : dspswit3/Counter  Direction=Up  CountEvent=Rising edge  CounterSize=32 bits  MaxCount=255  InitialCount=0  Output=Count  HitValue=32  ResetInput=on  SamplesPerFrame=1  Ts=1  CntDtype=double  HitDtype=Logical
  Fcn : Fcn  Expr=1/u
  Gain : Gain  Gain=2*(.01/60)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Memory : Memory
  Memory1 : Memory  InheritSampleTime=on
  Pulse Generator : DiscretePulseGenerator  PulseType=Time based  Amplitude=1  Period=.01/60  PulseWidth=50  PhaseDelay=0  SampleTime=1
  Sign : Signum
  Sign1 : Signum
  Sum : Sum  Inputs=|+-  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Triggered Subsystem : Subsystem  TreatAsAtomicUnit=on
  Triggered Subsystem1 : Subsystem  TreatAsAtomicUnit=on
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Left
  w (Hz) : Outport
  wires:
  Pulse Generator/1 -> Triggered Subsystem/Trigger, Counter/1
  Triggered Subsystem/1(Out1) -> Sign/1
  Sign/1 -> Sum/1, Memory/1
  Memory/1 -> Sum/2
  Sum/1 -> Abs/1
  Abs/1 -> Sign1/1
  Sign1/1 -> Counter/2, Triggered Subsystem1/Trigger
  Triggered Subsystem1/1(Out1) -> Gain/1
  Gain/1 -> Fcn/1
  Counter/1 -> Memory1/1
  Memory1/1 -> Triggered Subsystem1/1(In1)
  Voltage  Measurement/1 -> Triggered Subsystem/1(In1)
  Fcn/1 -> w (Hz)/1
  connections:
  Ground/LConn1 -- Voltage  Measurement/LConn2
  Va/RConn1 -- Voltage  Measurement/LConn1

== system uwm_mesh_grid_case3/measurement feeder C4/freq ==
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Counter : dspswit3/Counter  Direction=Up  CountEvent=Rising edge  CounterSize=32 bits  MaxCount=255  InitialCount=0  Output=Count  HitValue=32  ResetInput=on  SamplesPerFrame=1  Ts=1  CntDtype=double  HitDtype=Logical
  Fcn : Fcn  Expr=1/u
  Gain : Gain  Gain=2*(.01/60)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Memory : Memory
  Memory1 : Memory  InheritSampleTime=on
  Pulse Generator : DiscretePulseGenerator  PulseType=Time based  Amplitude=1  Period=.01/60  PulseWidth=50  PhaseDelay=0  SampleTime=1
  Sign : Signum
  Sign1 : Signum
  Sum : Sum  Inputs=|+-  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Triggered Subsystem : Subsystem  TreatAsAtomicUnit=on
  Triggered Subsystem1 : Subsystem  TreatAsAtomicUnit=on
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Left
  w (Hz) : Outport
  wires:
  Pulse Generator/1 -> Triggered Subsystem/Trigger, Counter/1
  Triggered Subsystem/1(Out1) -> Sign/1
  Sign/1 -> Sum/1, Memory/1
  Memory/1 -> Sum/2
  Sum/1 -> Abs/1
  Abs/1 -> Sign1/1
  Sign1/1 -> Counter/2, Triggered Subsystem1/Trigger
  Triggered Subsystem1/1(Out1) -> Gain/1
  Gain/1 -> Fcn/1
  Counter/1 -> Memory1/1
  Memory1/1 -> Triggered Subsystem1/1(In1)
  Voltage  Measurement/1 -> Triggered Subsystem/1(In1)
  Fcn/1 -> w (Hz)/1
  connections:
  Ground/LConn1 -- Voltage  Measurement/LConn2
  Va/RConn1 -- Voltage  Measurement/LConn1

== system uwm_mesh_grid_case3/measurement feeder C5/freq ==
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Counter : dspswit3/Counter  Direction=Up  CountEvent=Rising edge  CounterSize=32 bits  MaxCount=255  InitialCount=0  Output=Count  HitValue=32  ResetInput=on  SamplesPerFrame=1  Ts=1  CntDtype=double  HitDtype=Logical
  Fcn : Fcn  Expr=1/u
  Gain : Gain  Gain=2*(.01/60)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Memory : Memory
  Memory1 : Memory  InheritSampleTime=on
  Pulse Generator : DiscretePulseGenerator  PulseType=Time based  Amplitude=1  Period=.01/60  PulseWidth=50  PhaseDelay=0  SampleTime=1
  Sign : Signum
  Sign1 : Signum
  Sum : Sum  Inputs=|+-  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Triggered Subsystem : Subsystem  TreatAsAtomicUnit=on
  Triggered Subsystem1 : Subsystem  TreatAsAtomicUnit=on
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Left
  w (Hz) : Outport
  wires:
  Pulse Generator/1 -> Triggered Subsystem/Trigger, Counter/1
  Triggered Subsystem/1(Out1) -> Sign/1
  Sign/1 -> Sum/1, Memory/1
  Memory/1 -> Sum/2
  Sum/1 -> Abs/1
  Abs/1 -> Sign1/1
  Sign1/1 -> Counter/2, Triggered Subsystem1/Trigger
  Triggered Subsystem1/1(Out1) -> Gain/1
  Gain/1 -> Fcn/1
  Counter/1 -> Memory1/1
  Memory1/1 -> Triggered Subsystem1/1(In1)
  Voltage  Measurement/1 -> Triggered Subsystem/1(In1)
  Fcn/1 -> w (Hz)/1
  connections:
  Ground/LConn1 -- Voltage  Measurement/LConn2
  Va/RConn1 -- Voltage  Measurement/LConn1

== system uwm_mesh_grid_case3/measurement feeder C9/freq ==
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Counter : dspswit3/Counter  Direction=Up  CountEvent=Rising edge  CounterSize=32 bits  MaxCount=255  InitialCount=0  Output=Count  HitValue=32  ResetInput=on  SamplesPerFrame=1  Ts=1  CntDtype=double  HitDtype=Logical
  Fcn : Fcn  Expr=1/u
  Gain : Gain  Gain=2*(.01/60)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Memory : Memory
  Memory1 : Memory  InheritSampleTime=on
  Pulse Generator : DiscretePulseGenerator  PulseType=Time based  Amplitude=1  Period=.01/60  PulseWidth=50  PhaseDelay=0  SampleTime=1
  Sign : Signum
  Sign1 : Signum
  Sum : Sum  Inputs=|+-  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Triggered Subsystem : Subsystem  TreatAsAtomicUnit=on
  Triggered Subsystem1 : Subsystem  TreatAsAtomicUnit=on
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Left
  w (Hz) : Outport
  wires:
  Pulse Generator/1 -> Triggered Subsystem/Trigger, Counter/1
  Triggered Subsystem/1(Out1) -> Sign/1
  Sign/1 -> Sum/1, Memory/1
  Memory/1 -> Sum/2
  Sum/1 -> Abs/1
  Abs/1 -> Sign1/1
  Sign1/1 -> Counter/2, Triggered Subsystem1/Trigger
  Triggered Subsystem1/1(Out1) -> Gain/1
  Gain/1 -> Fcn/1
  Counter/1 -> Memory1/1
  Memory1/1 -> Triggered Subsystem1/1(In1)
  Voltage  Measurement/1 -> Triggered Subsystem/1(In1)
  Fcn/1 -> w (Hz)/1
  connections:
  Ground/LConn1 -- Voltage  Measurement/LConn2
  Va/RConn1 -- Voltage  Measurement/LConn1

== system uwm_mesh_grid_case3/microsource/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2

== system uwm_mesh_grid_case3/microsource/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case3/reset pulses/pulse ==
  Step : Step  Time=tstart  SampleTime=0
  Step1 : Step  Time=tstart+dt  After=-1  SampleTime=0
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case3/reset pulses/pulse1 ==
  Step : Step  Time=tstart  SampleTime=0
  Step1 : Step  Time=tstart+dt  After=-1  SampleTime=0
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case3/4 kW e-board5/trip/frequency estimator (discrete) ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag0  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Fcn/1 -> Product/2
  Constant/1 -> Sum/2
  modulo discrete integrator/1(Out1) -> Fcn/1
  Sum/1 -> modulo discrete integrator/1(In1), w/1
  Product/1 -> Filter1/1
  Filter1/1 -> Scope/1, Sum/1
  v/1 -> Gain/1
  Gain/1 -> Product/1

== system uwm_mesh_grid_case3/4 kW e-board6/trip/frequency estimator (discrete) ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag1  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Fcn/1 -> Product/2
  Constant/1 -> Sum/2
  modulo discrete integrator/1(Out1) -> Fcn/1
  Sum/1 -> modulo discrete integrator/1(In1), w/1
  Product/1 -> Filter1/1
  Filter1/1 -> Scope/1, Sum/1
  v/1 -> Gain/1
  Gain/1 -> Product/1

== system uwm_mesh_grid_case3/external storage/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=1000  LowerSaturationLimit=-1000
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case3/external storage/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=-.1667  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case3/genset/genset  controller/P-w droop ==
  note: P
  P_req : Inport
  P : Inport  Port=2
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  rad2pu : Gain  Gain=1/(2*pi*60)  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Outport
  wires:
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  P/1 -> limiter/1(In1), Sum2/2
  Sum3/1 -> rad2pu/1
  rad2pu/1 -> w/1

== system uwm_mesh_grid_case3/genset/genset  controller/PVQ computation ==
  note: P
  note: Q
  Vabc : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Iabc : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn3 : TransferFcn  Denominator=[.01 1]
  P_pu : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vt : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Q_pu : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Iabc/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  RMS/1 -> " pu convert V"/1
  Demux/2 -> " pu convert P"/1
  Demux/1 -> " pu convert S"/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  Vabc/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  Transfer Fcn1/1 -> P_pu/1
  " pu convert S"/1 -> Transfer Fcn1/1
  Transfer Fcn2/1 -> Q_pu/1
  " pu convert P"/1 -> Transfer Fcn2/1
  Transfer Fcn3/1 -> Vt/1
  " pu convert V"/1 -> Transfer Fcn3/1

== system uwm_mesh_grid_case3/genset/genset  controller/Q-E droop ==
  note: Q
  v_meas : Inport
  Q : Inport  Port=2
  E_req : Inport  Port=3
  PI-Control : Subsystem
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Vpk : Outport
  wires:
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  PI-Control/1(Out1) -> Vpk/1
  Q/1 -> "mQ droop "/1
  E_req/1 -> Sum/2
  v_meas/1 -> Sum1/2

== system uwm_mesh_grid_case3/genset/genset  controller/exciter ==
  wr : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Ef_mcd_wr : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation : Saturate  UpperLimit=10  LowerLimit=-10  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.001 1]
  Ef : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  wr/1 -> Product/2
  Ef_mcd_wr/1 -> Product/1
  Product/1 -> Saturation/1
  Saturation/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Ef/1

== system uwm_mesh_grid_case3/genset/genset  controller/ic_engine gpvernor ==
  wr : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmeas : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  IC_engine : Subsystem
  governor : Subsystem
  Pmech : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  governor/1(fuel_cmd) -> IC_engine/1(fuel_cmd)
  Pmeas/1 -> governor/1(Pmeas)
  IC_engine/1(Pmech) -> Pmech/1
  wr/1 -> governor/3(wr), IC_engine/2(wr)
  w/1 -> governor/2(w)

== system uwm_mesh_grid_case3/measurement feeder C1/freq/Triggered Subsystem ==
  In1 : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Trigger : TriggerPort
  Out1 : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  In1/1 -> Out1/1

== system uwm_mesh_grid_case3/measurement feeder C1/freq/Triggered Subsystem1 ==
  In1 : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Trigger : TriggerPort
  Out1 : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  In1/1 -> Out1/1

== system uwm_mesh_grid_case3/measurement feeder C4/freq/Triggered Subsystem ==
  In1 : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Trigger : TriggerPort
  Out1 : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  In1/1 -> Out1/1

== system uwm_mesh_grid_case3/measurement feeder C4/freq/Triggered Subsystem1 ==
  In1 : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Trigger : TriggerPort
  Out1 : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  In1/1 -> Out1/1

== system uwm_mesh_grid_case3/measurement feeder C5/freq/Triggered Subsystem ==
  In1 : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Trigger : TriggerPort
  Out1 : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  In1/1 -> Out1/1

== system uwm_mesh_grid_case3/measurement feeder C5/freq/Triggered Subsystem1 ==
  In1 : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Trigger : TriggerPort
  Out1 : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  In1/1 -> Out1/1

== system uwm_mesh_grid_case3/measurement feeder C9/freq/Triggered Subsystem ==
  In1 : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Trigger : TriggerPort
  Out1 : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  In1/1 -> Out1/1

== system uwm_mesh_grid_case3/measurement feeder C9/freq/Triggered Subsystem1 ==
  In1 : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Trigger : TriggerPort
  Out1 : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  In1/1 -> Out1/1

== system uwm_mesh_grid_case3/microsource/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case3/microsource/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case3/4 kW e-board5/trip/frequency estimator (discrete)/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Relational Operator/1 -> Discrete-Time Integrator/2
  Discrete-Time Integrator/State -> Gain1/1
  Gain1/1 -> Abs/1
  Constant1/1 -> Relational Operator/2, Math Function/2
  Abs/1 -> Relational Operator/1, Math Function/1
  In1/1 -> Discrete-Time Integrator/1
  Discrete-Time Integrator/1 -> Out1/1
  IC/1 -> Discrete-Time Integrator/3
  Math Function/1 -> IC/1
