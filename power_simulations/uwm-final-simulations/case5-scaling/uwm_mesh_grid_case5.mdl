simulink model "uwm_mesh_grid_case5"  (Simulink 7.5)
settings: Solver=ode45  StartTime=0.0  StopTime=3.0  RelTol=1e-4
undefined symbols (not defined in the file or in its folder): D1, Delta, dfilt, DiscIntNeverNeededParam
libraries: powerlib x236, powerlib_extras x62, dsparch4 x11
(part 6 of 6)

== system uwm_mesh_grid_case5/microsource3/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5/microsource3/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5/microsource4/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5/microsource4/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5/microsource5/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5/microsource5/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5/microsource6/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5/microsource6/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5/microsource7/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5/microsource7/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5/microsource8/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5/microsource8/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5/microsource9/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5/microsource9/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2
