simulink model "uwm_mesh_grid_case5b"  (Simulink 7.5)
settings: Solver=ode45  StartTime=0.0  StopTime=3.0  RelTol=1e-4
undefined symbols (not defined in the file or in its folder): D1, Delta, dfilt, DiscIntNeverNeededParam
libraries: powerlib x350, powerlib_extras x93, dsparch4 x16
(part 6 of 8)

== system uwm_mesh_grid_case5b/4 kW e-board12/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag6  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board2/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag7  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board3/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag8  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board4/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag9  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board5/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag10  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board6/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag11  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board7/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag12  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board8/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag13  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/4 kW e-board9/f-estimator ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag14  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Gain/1 -> Product/1
  v/1 -> Gain/1
  Filter1/1 -> Sum/1, Scope/1
  Product/1 -> Filter1/1
  Sum/1 -> w/1, modulo discrete integrator/1(In1)
  modulo discrete integrator/1(Out1) -> Fcn/1
  Constant/1 -> Sum/2
  Fcn/1 -> Product/2

== system uwm_mesh_grid_case5b/main grid/PC1 ==
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L  Capacitance=1/(336*2*pi*60)  Measurements=None
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  connections:
  A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Three-Phase Series RLC Branch3/RConn1 -- A/RConn1
  Three-Phase Series RLC Branch3/RConn2 -- B/RConn1
  Three-Phase Series RLC Branch3/RConn3 -- C/RConn1

== system uwm_mesh_grid_case5b/measurement feeder C3/frequency estimator (discrete) ==
  v : Inport
  Constant : Constant  Value=60  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Fcn : Fcn  Expr=sin(2*pi*u[1])
  Filter1 : dsparch4/Biquad Filter  Tag=BlockMethodSubSystem  DialogController=dspdialog.BiquadFilter  DialogControllerArgs=DataTag15  IIRFiltStruct=Direct form II  CoeffSource=Specify via dialog  BiQuadCoeffs=[1 -1.36 1 1 -1.78 0.87;1 1 0 1 -0.85 0]  a0Flag=Warning  IC=0  ICnum=0  ICden=0  denAccumFracLength=30  denProdOutputFracLength=30  secondMemoryFracLength=15  roundingMode=Floor  overflowMode=off  ScaleValues=[0.05;0.23;1]  optimizeScaleValues=on  ScaleValueMode=Specify via input port (g)  scaleValueFracLength=14  FilterSource=Specify via dialog  dfiltObjectName=dfilt.df2tsos([1 0.3 0.4],[1 0.1 0.2])
  Gain : Gain  Gain=1/150  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0  SampleTime=dt
  Product : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Scope : Scope
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  modulo discrete integrator : Subsystem  mask{dt=dt}
      mask prompts: dt "sample time"
  w : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Fcn/1 -> Product/2
  Constant/1 -> Sum/2
  modulo discrete integrator/1(Out1) -> Fcn/1
  Sum/1 -> modulo discrete integrator/1(In1), w/1
  Product/1 -> Filter1/1
  Filter1/1 -> Scope/1, Sum/1
  v/1 -> Gain/1
  Gain/1 -> Product/1

== system uwm_mesh_grid_case5b/microsource/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5b/microsource/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5b/microsource1/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5b/microsource1/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5b/microsource10/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5b/microsource10/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5b/microsource11/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5b/microsource11/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5b/microsource12/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5b/microsource12/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5b/microsource13/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5b/microsource13/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5b/microsource14/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5b/microsource14/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1
