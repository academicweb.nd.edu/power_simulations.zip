simulink model "uwm_mesh_grid_case5b"  (Simulink 7.5)
settings: Solver=ode45  StartTime=0.0  StopTime=3.0  RelTol=1e-4
undefined symbols (not defined in the file or in its folder): D1, Delta, dfilt, DiscIntNeverNeededParam
libraries: powerlib x350, powerlib_extras x93, dsparch4 x16
(part 3 of 8)

== system uwm_mesh_grid_case5b/PC01 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC1 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC12 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC2 ==
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Three-Phase Series RLC Branch3/RConn1 -- A/RConn1
  Three-Phase Series RLC Branch3/RConn2 -- B/RConn1
  Three-Phase Series RLC Branch3/RConn3 -- C/RConn1
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn3 -- Three-Phase Parallel RLC Branch/RConn1

== system uwm_mesh_grid_case5b/PC23 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC3 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC34 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC39 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC4 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC45 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC56 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC67 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC78 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC89 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC9A ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC9A1 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5b/PC9A2 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3
