simulink model "uwm_mesh_grid_case5b"  (Simulink 7.5)
settings: Solver=ode45  StartTime=0.0  StopTime=3.0  RelTol=1e-4
undefined symbols (not defined in the file or in its folder): D1, Delta, dfilt, DiscIntNeverNeededParam
libraries: powerlib x350, powerlib_extras x93, dsparch4 x16
(part 8 of 8)

== system uwm_mesh_grid_case5b/4 kW e-board4/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5b/4 kW e-board5/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5b/4 kW e-board6/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5b/4 kW e-board7/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5b/4 kW e-board8/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5b/4 kW e-board9/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5b/measurement feeder C3/frequency estimator (discrete)/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Relational Operator/1 -> Discrete-Time Integrator/2
  Discrete-Time Integrator/State -> Gain1/1
  Gain1/1 -> Abs/1
  Constant1/1 -> Relational Operator/2, Math Function/2
  Abs/1 -> Relational Operator/1, Math Function/1
  In1/1 -> Discrete-Time Integrator/1
  Discrete-Time Integrator/1 -> Out1/1
  IC/1 -> Discrete-Time Integrator/3
  Math Function/1 -> IC/1

== system uwm_mesh_grid_case5b/microsource/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource1/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource1/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource10/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource10/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource11/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource11/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource12/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource12/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource13/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource13/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource14/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource14/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource2/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource2/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource3/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource3/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource4/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource4/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource5/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource5/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource6/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource6/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource7/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource7/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource8/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource8/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5b/microsource9/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5b/microsource9/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2
