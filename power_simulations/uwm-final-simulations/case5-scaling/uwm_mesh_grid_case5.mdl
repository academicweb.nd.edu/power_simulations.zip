simulink model "uwm_mesh_grid_case5"  (Simulink 7.5)
settings: Solver=ode45  StartTime=0.0  StopTime=3.0  RelTol=1e-4
undefined symbols (not defined in the file or in its folder): D1, Delta, dfilt, DiscIntNeverNeededParam
libraries: powerlib x236, powerlib_extras x62, dsparch4 x11
(part 3 of 6)

== system uwm_mesh_grid_case5/PC9A ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Three-Phase Parallel RLC Branch : powerlib/Elements/Three-Phase Parallel RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=C  Resistance=1  Inductance=1e-3  Capacitance=1/(C*2*pi*60)  Measurements=None
  Three-Phase Series RLC Branch3 : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=RL  Resistance=R  Inductance=L/(2*pi*60)  Capacitance=1/(336*2*pi*60)  Measurements=None
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  A* : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  B* : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  C* : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  A : PMIOPort  Tag=PMCPort  Port=4  Side=Left
  B : PMIOPort  Tag=PMCPort  Port=5  Side=Left
  C : PMIOPort  Tag=PMCPort  Port=6  Side=Left
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  connections:
  Three-Phase Parallel RLC Branch/LConn1 -- A*/RConn1 -- Three-Phase Series RLC Branch3/LConn1
  Three-Phase Parallel RLC Branch/LConn2 -- B*/RConn1 -- Three-Phase Series RLC Branch3/LConn2
  Three-Phase Parallel RLC Branch/LConn3 -- C*/RConn1 -- Three-Phase Series RLC Branch3/LConn3
  Ground/LConn1 -- Three-Phase Parallel RLC Branch/RConn2 -- Three-Phase Parallel RLC Branch/RConn1 -- Three-Phase Parallel RLC Branch/RConn3
  Three-Phase V-I Measurement/RConn2 -- Three-Phase Series RLC Branch3/RConn2
  Three-Phase V-I Measurement/RConn3 -- Three-Phase Series RLC Branch3/RConn3
  Three-Phase V-I Measurement/RConn1 -- Three-Phase Series RLC Branch3/RConn1
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  C/RConn1 -- Three-Phase V-I Measurement/LConn3

== system uwm_mesh_grid_case5/disconnect event1 ==
  Step1 : Step  Time=[tstart]  Before=1  After=0  SampleTime=0
  Step2 : Step  Time=[tstop]  SampleTime=0
  Sum : Sum  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step2/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/disconnect event10 ==
  Step1 : Step  Time=[tstart]  Before=1  After=0  SampleTime=0
  Step2 : Step  Time=[tstop]  SampleTime=0
  Sum : Sum  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step2/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/disconnect event2 ==
  Step1 : Step  Time=[tstart]  Before=1  After=0  SampleTime=0
  Step2 : Step  Time=[tstop]  SampleTime=0
  Sum : Sum  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step2/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/disconnect event3 ==
  Step1 : Step  Time=[tstart]  Before=1  After=0  SampleTime=0
  Step2 : Step  Time=[tstop]  SampleTime=0
  Sum : Sum  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step2/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/disconnect event4 ==
  Step1 : Step  Time=[tstart]  Before=1  After=0  SampleTime=0
  Step2 : Step  Time=[tstop]  SampleTime=0
  Sum : Sum  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step2/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/disconnect event5 ==
  Step1 : Step  Time=[tstart]  Before=1  After=0  SampleTime=0
  Step2 : Step  Time=[tstop]  SampleTime=0
  Sum : Sum  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step2/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/disconnect event6 ==
  Step1 : Step  Time=[tstart]  Before=1  After=0  SampleTime=0
  Step2 : Step  Time=[tstop]  SampleTime=0
  Sum : Sum  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step2/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/disconnect event7 ==
  Step1 : Step  Time=[tstart]  Before=1  After=0  SampleTime=0
  Step2 : Step  Time=[tstop]  SampleTime=0
  Sum : Sum  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step2/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/disconnect event8 ==
  Step1 : Step  Time=[tstart]  Before=1  After=0  SampleTime=0
  Step2 : Step  Time=[tstop]  SampleTime=0
  Sum : Sum  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step2/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/disconnect event9 ==
  Step1 : Step  Time=[tstart]  Before=1  After=0  SampleTime=0
  Step2 : Step  Time=[tstop]  SampleTime=0
  Sum : Sum  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step2/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/main grid ==
  4.16kV 2500kVA : powerlib/Electrical Sources/Three-Phase Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Voltage=4160  PhaseAngle=0  Frequency=60  InternalConnection=Yg  SpecifyImpedance=on  Resistance=25^2/1000/10  Inductance=25^2/1000/377  ShortCircuitLevel=1200e6  BaseVoltage=4160  XRratio=100
  PC1 : Subsystem  mask{R=.093400, L=.025500, C=2894.3}
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 2500e3 , 60 ]  Winding1=[4160 .04706 .1882/(2*pi*60)]  Winding2Connection=Yg  Winding2=[480 .000627 .0025068/(2*pi*60)]  SetSaturation=off  Rm=1.e6  Lm=1.e6  Saturation=[0 0;589.26 2.1608;2.4552e+05 2.737]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[1.4405 -1.4405 1.2604]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  T2 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 75e3 , 60 ]  Winding1=[480 .0169 .0676/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 .0003 .0127/(2*pi*60)]  SetSaturation=off  Rm=1.e6  Lm=1.e6  Saturation=[0 0;589.26 2.1608;2.4552e+05 2.737]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[1.4405 -1.4405 1.2604]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  A : PMIOPort  Port=1  Side=Right
  B : PMIOPort  Port=2  Side=Right
  C : PMIOPort  Port=3  Side=Right
  connections:
  A/RConn1 -- T2/RConn1
  B/RConn1 -- T2/RConn2
  C/RConn1 -- T2/RConn3
  T1/RConn1 -- PC1/LConn1
  T1/RConn2 -- PC1/LConn2
  T1/RConn3 -- PC1/LConn3
  PC1/RConn1 -- T2/LConn1
  PC1/RConn2 -- T2/LConn2
  PC1/RConn3 -- T2/LConn3
  4.16kV 2500kVA/RConn2 -- T1/LConn2
  4.16kV 2500kVA/RConn1 -- T1/LConn1
  4.16kV 2500kVA/RConn3 -- T1/LConn3

== system uwm_mesh_grid_case5/measurement feeder C3 ==
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Ground : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  Voltage  Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  frequency estimator (discrete) : Subsystem  mask{dt=0.010}
      mask prompts: dt "sample time"
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  a : PMIOPort  Port=3  Side=Right
  b : PMIOPort  Port=4  Side=Right
  C : PMIOPort  Port=5  Side=Left
  c : PMIOPort  Port=6  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Three-Phase V-I Measurement/1 -> 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  Voltage  Measurement/1 -> frequency estimator (discrete)/1(v)
  frequency estimator (discrete)/1(w) -> freq/1
  connections:
  c/RConn1 -- Three-Phase V-I Measurement/RConn3
  C/RConn1 -- Three-Phase V-I Measurement/LConn3
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  a/RConn1 -- Three-Phase V-I Measurement/RConn1 -- Voltage  Measurement/LConn1
  B/RConn1 -- Three-Phase V-I Measurement/LConn2
  A/RConn1 -- Three-Phase V-I Measurement/LConn1
  Voltage  Measurement/LConn2 -- Ground/LConn1

== system uwm_mesh_grid_case5/microsource ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5/microsource1 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5/microsource2 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5/microsource3 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5/microsource4 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5/microsource5 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5/microsource6 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5/microsource7 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5/microsource8 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5/microsource9 ==
  E_req : Inport
  P_req : Inport  Port=2
  10 mH : powerlib/Elements/Three-Phase Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=A|B|C  RConnTagsString=A|B|C  BranchType=L  Resistance=.0028  Inductance=5e-3  Capacitance=1e-6  Measurements=None
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Gain : Gain  Gain=1/(2*pi)  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Mux : Mux  Inputs=2
  RMS block : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  RMS block1 : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  T1 : powerlib/Elements/Three-Phase Transformer (Two Windings)  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Winding1Connection=Delta (D1)  UNITS=SI  NominalPower=[ 45e3 , 60 ]  Winding1=[208 0.02688 0.1075/(2*pi*60)]  Winding2Connection=Yg  Winding2=[208 0.005047 .0201/(2*pi*60)]  SetSaturation=off  Rm=100.e6  Lm=7650.8  Saturation=[0 0;1359.8 0.93633;5.6659e+05 1.186]  Hysteresis=off  DataFile='hysteresis'  SetInitialFlux=off  InitialFluxes=[0.62422 -0.62422 0.54618]  Measurements=None  MoreParameters=off  BreakLoop=off  DataType=on  TransfoNumber=1
  Three-Phase V-I Measurement : powerlib/Measurements/Three-Phase V-I Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  VoltageMeasurement=phase-to-ground  SetLabelV=off  LabelV=Vabc  Vpu=off  VpuLL=off  CurrentMeasurement=yes  SetLabelI=off  LabelI=Iabc  Ipu=off  Pbase=100e6  Vbase=500e3  OutputType=Complex  PhasorSimulation=off  PSBequivalent=0
  UWM_controller : Subsystem  mask{Vbase=208, Sbase=15000}
  microsource : Subsystem
  a : PMIOPort  Port=1  Side=Right
  b : PMIOPort  Port=2  Side=Right
  c : PMIOPort  Port=3  Side=Right
  PQ : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  V : Outport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  I : Outport  Port=3  OutDataType=fixdt(1, 16)  OutScaling=2^0
  RMS : Outport  Port=4  OutDataType=fixdt(1, 16)  OutScaling=2^0
  freq : Outport  Port=5  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Pmm : Outport  Port=6
  wires:
  E_req/1 -> UWM_controller/3(E_req)
  P_req/1 -> UWM_controller/4(P_req)
  Three-Phase V-I Measurement/1 -> UWM_controller/1(v_meas), 3-phase  Instantaneous  Active & Reactive Power/1, RMS block1/1, V/1
  Three-Phase V-I Measurement/2 -> UWM_controller/2(i_meas), 3-phase  Instantaneous  Active & Reactive Power/2, RMS block/1, I/1
  UWM_controller/1(Vpk) -> microsource/1(Vpk)
  UWM_controller/2(w) -> microsource/2(w), Gain/1
  Gain/1 -> freq/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> PQ/1
  RMS block1/1 -> Mux/1
  RMS block/1 -> Mux/2
  Mux/1 -> RMS/1
  UWM_controller/3(Pmm) -> Pmm/1
  connections:
  b/RConn1 -- Three-Phase V-I Measurement/RConn2
  Three-Phase V-I Measurement/RConn3 -- c/RConn1
  10 mH/LConn2 -- microsource/RConn2
  10 mH/LConn1 -- microsource/RConn1
  10 mH/LConn3 -- microsource/RConn3
  T1/LConn1 -- 10 mH/RConn1
  T1/LConn2 -- 10 mH/RConn2
  T1/LConn3 -- 10 mH/RConn3
  T1/RConn1 -- Three-Phase V-I Measurement/LConn1
  T1/RConn2 -- Three-Phase V-I Measurement/LConn2
  T1/RConn3 -- Three-Phase V-I Measurement/LConn3
  a/RConn1 -- Three-Phase V-I Measurement/RConn1

== system uwm_mesh_grid_case5/reset pulses ==
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  pulse : Subsystem  mask{tstart=tpulse(1), dt=.1}
  pulse1 : Subsystem  mask{tstart=tpulse(2), dt=.1}
  Out1 : Outport
  wires:
  pulse/1(Out1) -> Sum/1
  pulse1/1(Out1) -> Sum/2
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/smart coupler1 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3

== system uwm_mesh_grid_case5/smart coupler10 ==
  event : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Abs : Abs  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Level-2 M-file S-Function : M-S-Function  FunctionName=smart_coupler
  SS2 : powerlib/Elements/Three-Phase Breaker  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  InitialState=open  SwitchA=on  SwitchB=on  SwitchC=on  SwitchTimes=[5 6]  External=on  BreakerResistance=.001  SnubberResistance=1e6  SnubberCapacitance=inf  Measurements=None
  Scope : Scope  NumInputPorts=3
  Transfer Fcn : TransferFcn  Numerator=[100]  Denominator=[1 100]
  Voltage Measurement : powerlib/Measurements/Voltage Measurement  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  PhasorSimulation=off  OutputType=Complex  PSBequivalent=0
  A : PMIOPort  Port=1  Side=Left
  B : PMIOPort  Port=2  Side=Left
  C : PMIOPort  Port=3  Side=Left
  a : PMIOPort  Port=4  Side=Right
  b : PMIOPort  Port=5  Side=Right
  c : PMIOPort  Port=6  Side=Right
  connected : Outport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  wires:
  Level-2 M-file S-Function/1 -> Scope/1, SS2/1, connected/1
  Voltage Measurement/1 -> Abs/1
  Abs/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Level-2 M-file S-Function/1, Scope/3
  event/1 -> Level-2 M-file S-Function/2, Scope/2
  connections:
  A/RConn1 -- SS2/LConn1 -- Voltage Measurement/LConn1
  Voltage Measurement/LConn2 -- a/RConn1 -- SS2/RConn1
  B/RConn1 -- SS2/LConn2
  C/RConn1 -- SS2/LConn3
  b/RConn1 -- SS2/RConn2
  c/RConn1 -- SS2/RConn3
