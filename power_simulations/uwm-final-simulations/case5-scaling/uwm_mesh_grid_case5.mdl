simulink model "uwm_mesh_grid_case5"  (Simulink 7.5)
settings: Solver=ode45  StartTime=0.0  StopTime=3.0  RelTol=1e-4
undefined symbols (not defined in the file or in its folder): D1, Delta, dfilt, DiscIntNeverNeededParam
libraries: powerlib x236, powerlib_extras x62, dsparch4 x11
(part 5 of 6)

== system uwm_mesh_grid_case5/microsource4/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5/microsource4/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5/microsource5/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5/microsource5/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5/microsource6/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5/microsource6/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5/microsource7/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5/microsource7/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5/microsource8/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5/microsource8/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5/microsource9/UWM_controller ==
  note: P
  note: Q
  v_meas : Inport
  i_meas : Inport  Port=2
  E_req : Inport  Port=3
  P_req : Inport  Port=4
  " pu convert P" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert S" : Gain  Gain=1/Sbase  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  " pu convert V" : Gain  Gain=1/(Vbase/sqrt(3))  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  3-phase  Instantaneous  Active & Reactive Power : powerlib_extras/Measurements/3-phase  Instantaneous  Active & Reactive Power  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1
  Demux : Demux  Outputs=2
  PI-Control : Subsystem
  RMS : Fcn  Expr=sqrt(u(1)*u(1)+u(2)*u(2)+u(3)*u(3))/sqrt(3)
  Sum : Sum  Inputs=|-+  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=+-|  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  Inputs=+++  OutDataType=sfix(16)  OutScaling=2^0
  Transfer Fcn : TransferFcn  Denominator=[.01 1]
  Transfer Fcn1 : TransferFcn  Denominator=[.01 1]
  Transfer Fcn2 : TransferFcn  Denominator=[.01 1]
  k : Gain  Gain=1/pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  limiter : Subsystem
  mP droop : Gain  Gain=pi  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  "mQ droop " : Gain  Gain=0.05  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  w0 : Constant  Value=60*2*pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Vpk : Outport
  w : Outport  Port=2
  Pmm : Outport  Port=3
  wires:
  Transfer Fcn2/1 -> " pu convert V"/1
  Transfer Fcn/1 -> " pu convert P"/1
  " pu convert P"/1 -> "mQ droop "/1
  Transfer Fcn1/1 -> " pu convert S"/1
  " pu convert S"/1 -> limiter/1(In1), Sum2/2
  i_meas/1 -> 3-phase  Instantaneous  Active & Reactive Power/2
  P_req/1 -> Sum2/1
  mP droop/1 -> Sum3/2
  limiter/1(Out1) -> Sum3/1, k/1
  w0/1 -> Sum3/3
  Sum2/1 -> mP droop/1
  Sum1/1 -> PI-Control/1(In1)
  Sum/1 -> Sum1/1
  "mQ droop "/1 -> Sum/1
  RMS/1 -> Transfer Fcn2/1
  Demux/2 -> Transfer Fcn/1
  Demux/1 -> Transfer Fcn1/1
  3-phase  Instantaneous  Active & Reactive Power/1 -> Demux/1
  v_meas/1 -> RMS/1, 3-phase  Instantaneous  Active & Reactive Power/1
  PI-Control/1(Out1) -> Vpk/1
  Sum3/1 -> w/1
  E_req/1 -> Sum/2
  " pu convert V"/1 -> Sum1/2
  k/1 -> Pmm/1

== system uwm_mesh_grid_case5/microsource9/microsource ==
  Vpk : Inport  OutDataType=fixdt(1, 16)  OutScaling=2^0
  w : Inport  Port=2  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Ground2 : powerlib/Elements/Ground  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=a
  Integrator : Integrator
  Mux : Mux  Inputs=3
  Product : Product  OutDataType=sfix(16)  OutScaling=2^0
  Series RLC Branch : powerlib/Elements/Series RLC Branch  DialogController=POWERSYS.PowerSysDialog  PhysicalDomain=powersysdomain  SubClassName=unknown  LeftPortType=p1  RightPortType=p1  LConnTagsString=__new0  RConnTagsString=__new0  BranchType=C  Resistance=1  Inductance=1e-3  SetiL0=off  InitialCurrent=0  Capacitance=1e-8  Setx0=off  InitialVoltage=0  Measurements=None
  phaseA : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseB : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  phaseC : powerlib/Electrical Sources/Controlled Voltage Source  DialogController=POWERSYS.PowerSysDialog  SystemSampleTime=-1  Initialize=on  Source_Type=AC  Amplitude=0  Phase=0  Frequency=0  Measurements=None
  v_A : Fcn  Expr=cos(u)
  v_B : Fcn  Expr=cos(u-2*pi/3)
  v_C : Fcn  Expr=cos(u+2*pi/3)
  Va : PMIOPort  Tag=PMCPort  Port=1  Side=Right
  Vb : PMIOPort  Tag=PMCPort  Port=2  Side=Right
  Vc : PMIOPort  Tag=PMCPort  Port=3  Side=Right
  wires:
  Product/1 -> Demux/1
  Vpk/1 -> Product/1
  Mux/1 -> Product/2
  w/1 -> Integrator/1
  Integrator/1 -> v_A/1, v_B/1, v_C/1
  v_A/1 -> Mux/1
  v_B/1 -> Mux/2
  v_C/1 -> Mux/3
  Demux/1 -> phaseA/1
  Demux/2 -> phaseB/1
  Demux/3 -> phaseC/1
  connections:
  Vb/RConn1 -- phaseB/RConn1 -- phaseA/LConn1
  Va/RConn1 -- phaseC/LConn1 -- phaseA/RConn1
  Vc/RConn1 -- phaseC/RConn1
  Series RLC Branch/RConn1 -- Ground2/LConn1
  Series RLC Branch/LConn1 -- phaseB/LConn1

== system uwm_mesh_grid_case5/reset pulses/pulse ==
  Step : Step  Time=tstart  SampleTime=0
  Step1 : Step  Time=tstart+dt  After=-1  SampleTime=0
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/reset pulses/pulse1 ==
  Step : Step  Time=tstart  SampleTime=0
  Step1 : Step  Time=tstart+dt  After=-1  SampleTime=0
  Sum : Sum  Inputs=|++  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Step/1 -> Sum/2
  Step1/1 -> Sum/1
  Sum/1 -> Out1/1

== system uwm_mesh_grid_case5/2 kW e-board5/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5/2 kW e-board9/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5/4 kW e-board1/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5/4 kW e-board10/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5/4 kW e-board2/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5/4 kW e-board3/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5/4 kW e-board4/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5/4 kW e-board6/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5/4 kW e-board7/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5/4 kW e-board8/f-estimator/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Math Function/1 -> IC/1
  IC/1 -> Discrete-Time Integrator/3
  Discrete-Time Integrator/1 -> Out1/1
  In1/1 -> Discrete-Time Integrator/1
  Abs/1 -> Math Function/1, Relational Operator/1
  Constant1/1 -> Math Function/2, Relational Operator/2
  Gain1/1 -> Abs/1
  Discrete-Time Integrator/State -> Gain1/1
  Relational Operator/1 -> Discrete-Time Integrator/2

== system uwm_mesh_grid_case5/measurement feeder C3/frequency estimator (discrete)/modulo discrete integrator ==
  In1 : Inport
  Abs : Abs
  Constant1 : Constant  OutDataType=sfix(16)  OutScaling=2^0
  Discrete-Time Integrator : DiscreteIntegrator  ExternalReset=rising  InitialConditionSource=external  SampleTime=dt  OutDataType=fixdt(1, 16)  OutScaling=2^0  UpperSaturationLimit=100  LowerSaturationLimit=-100  ShowStatePort=on  ICPrevOutput=DiscIntNeverNeededParam  ICPrevScaledInput=DiscIntNeverNeededParam
  Gain1 : Gain  Gain=1+.0001  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  IC : InitialCondition  Value=0
  Math Function : Math  Operator=rem  OutDataType=sfix(16)  OutScaling=2^0
  Relational Operator : RelationalOperator
  Out1 : Outport
  wires:
  Relational Operator/1 -> Discrete-Time Integrator/2
  Discrete-Time Integrator/State -> Gain1/1
  Gain1/1 -> Abs/1
  Constant1/1 -> Relational Operator/2, Math Function/2
  Abs/1 -> Relational Operator/1, Math Function/1
  In1/1 -> Discrete-Time Integrator/1
  Discrete-Time Integrator/1 -> Out1/1
  IC/1 -> Discrete-Time Integrator/3
  Math Function/1 -> IC/1

== system uwm_mesh_grid_case5/microsource/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5/microsource/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5/microsource1/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5/microsource1/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2

== system uwm_mesh_grid_case5/microsource2/UWM_controller/PI-Control ==
  In1 : Inport
  Gain : Gain  Gain=.01  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain1 : Gain  Gain=5  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Gain2 : Gain  Gain=750  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=100  LowerSaturationLimit=-100  ZeroCross=off
  Sum4 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Gain/1 -> Sum4/1
  Integrator1/1 -> Sum4/2
  In1/1 -> Gain1/1, Gain/1
  Gain1/1 -> Integrator1/1
  Sum4/1 -> Gain2/1
  Gain2/1 -> Out1/1

== system uwm_mesh_grid_case5/microsource2/UWM_controller/limiter ==
  In1 : Inport
  Integrator1 : Integrator  LimitOutput=on  UpperSaturationLimit=0  LowerSaturationLimit=-pi  ZeroCross=off
  Integrator2 : Integrator  LimitOutput=on  UpperSaturationLimit=pi  LowerSaturationLimit=0  ZeroCross=off
  Kilim : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kilim1 : Gain  Gain=30  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Kplim1 : Gain  Gain=3  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit : Constant  Value=1.0  OutDataType=sfix(16)  OutScaling=2^0
  Plimit1 : Constant  Value=0.0  OutDataType=sfix(16)  OutScaling=2^0
  Saturation1 : Saturate  UpperLimit=pi  LowerLimit=0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Saturation2 : Saturate  UpperLimit=0  LowerLimit=-pi  OutDataType=fixdt(1, 16)  OutScaling=2^0
  Sum1 : Sum  Inputs=-+|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum3 : Sum  OutDataType=sfix(16)  OutScaling=2^0
  Sum4 : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum9 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Out1 : Outport
  wires:
  Sum3/1 -> Out1/1
  Plimit1/1 -> Sum1/2
  Integrator2/1 -> Sum2/2
  Kilim1/1 -> Integrator2/1
  Sum1/1 -> Kilim1/1, Kplim1/1
  In1/1 -> Sum1/1, Sum4/2
  Integrator1/1 -> Sum9/2
  Kilim/1 -> Integrator1/1
  Sum4/1 -> Kilim/1, Kplim/1
  Plimit/1 -> Sum4/1
  Kplim1/1 -> Saturation1/1
  Saturation1/1 -> Sum2/1
  Kplim/1 -> Saturation2/1
  Saturation2/1 -> Sum9/1
  Sum9/1 -> Sum3/1
  Sum2/1 -> Sum3/2
